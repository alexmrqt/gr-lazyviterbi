options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: base_dir
  id: variable
  parameters:
    value: '"PATH TO MODULE DIRECTORY"'
  states: {state: disabled}
- name: base_dir
  id: variable
  parameters:
    value: '"/home/amarquet/Documents/sdr/gr-lazyviterbi"'
  states: {}
- name: fsm
  id: variable
  parameters:
    value: trellis.fsm(base_dir+"/examples/fsm/5_7.fsm")
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: byte
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: byte
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: fec_ber_bf_0_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: fec_ber_bf_0_0_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: fec_ber_bf_0_0_0_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: lazyviterbi_dynamic_viterbi_0
  id: lazyviterbi_dynamic_viterbi
  parameters:
    block_size: '1024'
    final_state: '-1'
    fsm_args: fsm
    init_state: '0'
    thres: '15.0'
  states: {}
- name: lazyviterbi_lazy_viterbi_0
  id: lazyviterbi_lazy_viterbi
  parameters:
    block_size: '1024'
    final_state: '-1'
    fsm_args: fsm
    init_state: '0'
    thres: '15.0'
  states: {}
- name: lazyviterbi_viterbi_0
  id: lazyviterbi_viterbi
  parameters:
    block_size: '1024'
    final_state: '-1'
    fsm_args: fsm
    init_state: '0'
    thres: '15.0'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: 1,1
    min: '0'
    name: '"Lazy"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: 1,2
    min: '0'
    name: '"Standard (gr-trellis)"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: 1,3
    min: '0'
    name: '"Standard (gr-lazyviterbi)"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: 1,4
    min: '0'
    name: '"Dynamic"'
    type: float
  states: {}
- name: trellis_encoder_xx_0
  id: trellis_encoder_xx
  parameters:
    fsm_args: fsm
    init_state: '0'
    type: bb
  states: {}
- name: trellis_metrics_x_0
  id: trellis_metrics_x
  parameters:
    card: fsm.O()
    dim: fsm.I()
    metric_type: digital.TRELLIS_EUCLIDEAN
    table: '[-1, -1, -1, 1, 1, -1, 1, 1]'
    type: f
  states: {}
- name: trellis_viterbi_x_0
  id: trellis_viterbi_x
  parameters:
    block_size: '1024'
    final_state: '-1'
    fsm_args: fsm
    init_state: '0'
    type: b
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_random_source_x_0, '0', trellis_encoder_xx_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_0, '0', fec_ber_bf_0, '1']
- [blocks_delay_0_0, '0', fec_ber_bf_0_0, '1']
- [blocks_delay_0_0_0, '0', fec_ber_bf_0_0_0, '1']
- [blocks_delay_0_0_0_0, '0', fec_ber_bf_0_0_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_throttle_0, '0', trellis_metrics_x_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [fec_ber_bf_0_0, '0', qtgui_number_sink_0_0, '0']
- [fec_ber_bf_0_0_0, '0', qtgui_number_sink_0_0_0, '0']
- [fec_ber_bf_0_0_0_0, '0', qtgui_number_sink_0_0_0_0, '0']
- [lazyviterbi_dynamic_viterbi_0, '0', blocks_delay_0_0_0_0, '0']
- [lazyviterbi_lazy_viterbi_0, '0', blocks_delay_0, '0']
- [lazyviterbi_viterbi_0, '0', blocks_delay_0_0_0, '0']
- [trellis_encoder_xx_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [trellis_metrics_x_0, '0', lazyviterbi_dynamic_viterbi_0, '0']
- [trellis_metrics_x_0, '0', lazyviterbi_lazy_viterbi_0, '0']
- [trellis_metrics_x_0, '0', lazyviterbi_viterbi_0, '0']
- [trellis_metrics_x_0, '0', trellis_viterbi_x_0, '0']
- [trellis_viterbi_x_0, '0', blocks_delay_0_0, '0']
- [virtual_source_0, '0', fec_ber_bf_0, '0']
- [virtual_source_0, '0', fec_ber_bf_0_0, '0']
- [virtual_source_0, '0', fec_ber_bf_0_0_0, '0']
- [virtual_source_0, '0', fec_ber_bf_0_0_0_0, '0']

metadata:
  file_format: 1
